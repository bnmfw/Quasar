.include dis/bulk.pm
.include dis/7nm_FF.pm
.include dis/sg13g2_moslv_mod.lib
.include dis/logica.cir
.include dis/DFF.cir
.include include/all.cir
