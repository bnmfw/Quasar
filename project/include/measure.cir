*File with measures of lowest and highest values in node and output
.meas tran minout min V(sc2) from=1.0n to=3.8n
.meas tran maxout max V(sc2) from=1.0n to=3.8n
.meas tran minnod min V(n4) from=1.0n to=3.8n
.meas tran maxnod max V(n4) from=1.0n to=3.8n
