.option measform = 3
.option post = 2
