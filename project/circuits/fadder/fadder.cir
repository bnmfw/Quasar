Full Adder do Rafael Neves

****** Includes ******

.include ../../include.cir

****** HGSPICE ******

.option measform = 3
.option post = 0

Mp1 vdd a p1_p2 vdd 					PMOS_BULK w=140n l=32n
Mp2 p1_p2 b p2_n1 vdd 					PMOS_BULK w=140n l=32n
Mp3 vdd a p3_p4 vdd 					PMOS_BULK w=140n l=32n
Mp4 p3_p4 cin p2_n1 vdd 				PMOS_BULK w=140n l=32n
Mp5 vdd b p3_p4 vdd 					PMOS_BULK w=140n l=32n
Mp6 vdd cin p6_p9 vdd 					PMOS_BULK w=140n l=32n
Mp7 vdd a p6_p9 vdd 					PMOS_BULK w=140n l=32n
Mp8 vdd b p6_p9 vdd 					PMOS_BULK w=140n l=32n
Mp9 p6_p9 p2_n1 p9_n6 vdd 				PMOS_BULK w=140n l=32n
Mp10 vdd a p10_p11 vdd 					PMOS_BULK w=140n l=32n
Mp11 p10_p11 b p11_p12 vdd 				PMOS_BULK w=140n l=32n
Mp12 p11_p12 cin p9_n6 vdd 				PMOS_BULK w=140n l=32n

Mn1 p2_n1 b n1_n2 gnd 					NMOS_BULK w=70n l=32n
Mn2 n1_n2 a vss gnd 					NMOS_BULK w=70n l=32n
Mn3 n4_n3 a vss gnd 					NMOS_BULK w=70n l=32n
Mn4 p2_n1 cin n4_n3 gnd 				NMOS_BULK w=70n l=32n
Mn5 n4_n3 b vss gnd 					NMOS_BULK w=70n l=32n
Mn6 p9_n6 p2_n1 n6_n7 gnd 				NMOS_BULK w=70n l=32n
Mn7 n6_n7 cin vss gnd 					NMOS_BULK w=70n l=32n
Mn8 n6_n7 a vss gnd 					NMOS_BULK w=70n l=32n
Mn9 n6_n7 b vss gnd 					NMOS_BULK w=70n l=32n
Mn10 p9_n6 cin i10 gnd					NMOS_BULK w=70n l=32n
Mn11 i10 b i11 gnd 					    NMOS_BULK w=70n l=32n
Mn12 i11 a vss gnd 				        NMOS_BULK w=70n l=32n

Mp13 vdd p9_n6 sum vdd 					PMOS_BULK w=140n l=32n
Mn13 sum p9_n6 vss gnd 					NMOS_BULK w=70n l=32n
Mp14 vdd p2_n1 cout vdd 				PMOS_BULK w=140n l=32n
Mn14 cout p2_n1 vss gnd 				NMOS_BULK w=70n l=32n

.end
