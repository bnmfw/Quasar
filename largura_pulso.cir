*Arquivo com a leitura da largura dos pulsos
.meas tran atraso TRIG v(i6) val='0.35' rise=1 TARG v(g2) val='0.35' rise=1
.meas tran larg TRIG v(i6) val='0.35' rise=1 TARG v(i6) val='0.35' fall=1
