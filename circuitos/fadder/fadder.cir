Full Adder do Rafael Neves

****** Includes ******

.include ../include.cir

****** HGSPICE ******

.option measform = 3
.option post = 0

***** FAN IN ******
Mp1inva4 vdd a na vdd          		pmos_rvt w=27.0n l=20n nfin=3
Mn1inva4 na a vss gnd   			nmos_rvt w=27.0n l=20n nfin=3
Mp1invb4 vdd b nb vdd          		pmos_rvt w=27.0n l=20n nfin=3
Mn1invb4 nb b vss gnd   			nmos_rvt w=27.0n l=20n nfin=3
Mp1invcin4 vdd cin ncin vdd         pmos_rvt w=27.0n l=20n nfin=3
Mn1invcin4 ncin cin gnd gnd   	nmos_rvt w=27.0n l=20n nfin=3

Mp2inva4 vcc na ta vdd          		pmos_rvt w=27.0n l=20n nfin=3
Mn2inva4 ta na vss gnd   			nmos_rvt w=27.0n l=20n nfin=3
Mp2invb4 vcc nb tb vdd          		pmos_rvt w=27.0n l=20n nfin=3
Mn2invb4 tb nb vss gnd   			nmos_rvt w=27.0n l=20n nfin=3
Mp2invcin4 vdd ncin tcin vdd         pmos_rvt w=27.0n l=20n nfin=3
Mn2invcin4 tcin ncin vss gnd   	nmos_rvt w=27.0n l=20n nfin=3

****** START QUASAR ******
Mp1 vdd ta p1_p2 vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mp2 p1_p2 tb p2_n1 vdd 						pmos_rvt w=27.0n l=20n nfin=3
Mp3 vdd ta p3_p4 vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mp4 p3_p4 tcin p2_n1 vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mp5 vdd tb p3_p4 vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mp6 vdd tcin p6_p9 vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mp7 vdd ta p6_p9 vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mp8 vdd tb p6_p9 vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mp9 p6_p9 p2_n1 p9_n6 vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mp10 vdd ta p10_p11 vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mp11 p10_p11 tb p11_p12 vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mp12 p11_p12 tcin p9_n6 vdd 					pmos_rvt w=27.0n l=20n nfin=3

Mn1 p2_n1 tb n1_n2 gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mn2 n1_n2 ta vss gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mn3 n4_n3 ta vss gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mn4 p2_n1 tcin n4_n3 gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mn5 n4_n3 tb vss gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mn6 p9_n6 p2_n1 n6_n7 gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mn7 n6_n7 tcin vss gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mn8 n6_n7 ta vss gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mn9 n6_n7 tb vss gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mn10 p9_n6 tcin i10 gnd					nmos_rvt w=27.0n l=20n nfin=3
Mn11 i10 tb i11 gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mn12 i11 ta vss gnd 				nmos_rvt w=27.0n l=20n nfin=3

Mp13 vdd p9_n6 sum vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mn13 sum p9_n6 vss gnd 					nmos_rvt w=27.0n l=20n nfin=3
Mp14 vdd p2_n1 cout vdd 					pmos_rvt w=27.0n l=20n nfin=3
Mn14 cout p2_n1 vss gnd 				nmos_rvt w=27.0n l=20n nfin=3

Mp1fout4S vdd sum nsum vdd          	pmos_rvt w=27.0n l=20n nfin=4
Mn1fout4S nsum sum vss gnd   		nmos_rvt w=27.0n l=20n nfin=4

Mp1fout4C vdd cout ncout vdd         pmos_rvt w=27.0n l=20n nfin=4
Mn1fout4C ncout cout vss gnd   	nmos_rvt w=27.0n l=20n nfin=4

**** END QUASAR ****

*dcell node cout
Mp15 vdd gate_p15 drain_p15 vdd 				pmos_rvt w=27.0n l=20n nfin=3
Mn15 gate_p15 drain_p15 cout gnd				nmos_rvt w=27.0n l=20n nfin=3
Mp16 cout gate_p16 drain_p16 vdd					pmos_rvt w=27.0n l=20n nfin=3
Mn16 gate_p16 drain_p16 gnd gnd				nmos_rvt w=27.0n l=20n nfin=3

*dcell node cout
Mp25 vdd gate_q15 drain_q15 vdd 				pmos_rvt w=27.0n l=20n nfin=3
Mn25 gate_q15 drain_q15 sum gnd				nmos_rvt w=27.0n l=20n nfin=3
Mp26 sum gate_q16 drain_q16 vdd					pmos_rvt w=27.0n l=20n nfin=3
Mn26 gate_q16 drain_q16 gnd gnd				nmos_rvt w=27.0n l=20n nfin=3

.end
