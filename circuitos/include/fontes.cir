*Input signals to be altered by Quasar
VinSel inSel gnd 0.9
VinA inA gnd 0.0
VinB inB gnd 0.9
