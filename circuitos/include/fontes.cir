*Input signals to be altered by Quasar
Va a gnd 0.0
Vb b gnd 0.0
Vc c gnd 0.7
Vd d gnd 0.0
Ve e gnd 0.0
