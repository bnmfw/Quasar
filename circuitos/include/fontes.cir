*Input signals to be altered by Quasar
Va a gnd 0.7
Vb b gnd 0.7
Vc c gnd 0.0
Vd d gnd 0.7
Ve e gnd 0.7
