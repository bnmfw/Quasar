*Input signals to be altered by Quasar
Va a gnd 0.7
Vb b gnd 0.7
Vcin cin gnd 0.7
