*Arquivo com a leitura da largura dos pulsos
.meas tran larg TRIG v(e2) val='0.35' rise=1 TARG v(e2) val='0.35' fall=1
