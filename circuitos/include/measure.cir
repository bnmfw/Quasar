*File with measures of lowest and highest values in node and output
.meas tran minout min V(g1) from=1.0n to=3.8n
.meas tran maxout max V(g1) from=1.0n to=3.8n
.meas tran minnod min V(g1) from=1.0n to=3.8n
.meas tran maxnod max V(g1) from=1.0n to=3.8n
