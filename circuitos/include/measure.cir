*File with measures of lowest and highest values in node and output
.meas tran minout min V(axorb) from=1.0n to=3.8n
.meas tran maxout max V(axorb) from=1.0n to=3.8n
