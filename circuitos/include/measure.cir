*File with measures of lowest and highest values in node and output
.meas tran minout min V(g2) from=1.0n to=3.8n
.meas tran maxout max V(g2) from=1.0n to=3.8n
.meas tran minnod min V(e5) from=1.0n to=3.8n
.meas tran maxnod max V(e5) from=1.0n to=3.8n
