*SETs para serem usados nos benchmarks
Iseu gnd i6 EXP(0 249.5u 2n 50p 164p 200p) //rise
*Iseu i6 gnd EXP(0 249.5u 2n 50p 164p 200p) //fall
.meas tran minout min V(g2) from=1.0n to=3.8n
.meas tran maxout max V(g2) from=1.0n to=3.8n
.meas tran minnod min V(i6) from=1.0n to=3.8n
.meas tran maxnod max V(i6) from=1.0n to=3.8n
.meas tran mincor min i(Vmeasg2) from=1.0n to=3.8n
.meas tran maxcor max i(Vmeasg2) from=1.0n to=3.8n
