*File with measured of lowest and highest values in list of nodes
.meas tran ming1 min V(g1) from=1.0n to=3.8n
.meas tran maxg1 max V(g1) from=1.0n to=3.8n
