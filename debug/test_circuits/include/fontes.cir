*Input signals to be altered by Quasar
Va a gnd 0.7
Vb b gnd 0.7
Vc cin gnd 0.7
