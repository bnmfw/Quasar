* Facilitador de includes
.include option.cir
.include fontes.cir
.include params.cir
.include measure.cir
.include monte_carlo.cir
.include SETs.cir
.include vdd.cir
.include vss.cir
.include models.pm
