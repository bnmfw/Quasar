.include dis/logica.cir
.include dis/DFF.cir
.include include/all.cir
